# Keil uVision project ble_app_uart.uvproj, settings and files
target xxaa_s110 (256K)_HW12 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD,HW_VER = HW_VER_12
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\s110
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../../Main_Project/arm/: LED.c
    ./: ADC.c KEY.c RTC0.c spi_master.c TIMER.c BLE.c MainWork.c CRC16.c BLEhandle.c ADS1248.c FLASH.c
  group Services
    ../: ble_nus.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../Source/ble/: ble_advdata.c ble_conn_params.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/app_common/: app_timer.c
target xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
target xxaa_s110 (256K)_HW13 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD, HW_VER = HW_VER_13
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
